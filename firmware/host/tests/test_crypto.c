#include <stdio.h>
#include <string.h>

#include "proto_crypto.h"

static int failures;

#define CHECK(cond)                                                            \
    do {                                                                       \
        if (!(cond)) {                                                         \
            printf("FAIL %s:%d: %s\n", __FILE__, __LINE__, #cond);             \
            failures++;                                                        \
        }                                                                      \
    } while (0)

/* NSA Simon & Speck paper, Appendix C, byte form (little-endian words). */
static const uint8_t KAT_A_KEY[16] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f
};
static const uint8_t KAT_A_PT[16] = {
    0x20, 0x6d, 0x61, 0x64, 0x65, 0x20, 0x69, 0x74,
    0x20, 0x65, 0x71, 0x75, 0x69, 0x76, 0x61, 0x6c
};
static const uint8_t KAT_A_CT[16] = {
    0x18, 0x0d, 0x57, 0x5c, 0xdf, 0xfe, 0x60, 0x78,
    0x65, 0x32, 0x78, 0x79, 0x51, 0x98, 0x5d, 0xa6
};

static void test_speck_kat_a(void) {
    speck128_key_t key;
    uint8_t out[16];

    speck128_set_key(&key, KAT_A_KEY);
    speck128_encrypt(&key, KAT_A_PT, out);
    if (memcmp(out, KAT_A_CT, sizeof out) != 0) {
        printf("  got:");
        for (size_t i = 0; i < sizeof out; i++) printf(" %02x", out[i]);
        printf("\n");
    }
    CHECK(memcmp(out, KAT_A_CT, sizeof out) == 0);
}

/* --- Test-only AES-128 block primitive for RFC 4493 CMAC vectors --- */

typedef struct {
    uint8_t rk[176];
} test_aes128_t;

static const uint8_t AES_SBOX[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

static uint8_t xtime8(uint8_t x) {
    return (uint8_t)((uint8_t)(x << 1) ^ ((x & 0x80u) ? 0x1bu : 0u));
}

static void aes128_init(test_aes128_t *ctx, const uint8_t key[16]) {
    unsigned i;
    uint8_t rcon = 1;
    memcpy(ctx->rk, key, 16);
    for (i = 16; i < 176; i += 4) {
        uint8_t t[4] = { ctx->rk[i-4], ctx->rk[i-3], ctx->rk[i-2], ctx->rk[i-1] };
        if (i % 16u == 0u) {
            uint8_t tmp = t[0];
            t[0] = (uint8_t)(AES_SBOX[t[1]] ^ rcon);
            t[1] = AES_SBOX[t[2]];
            t[2] = AES_SBOX[t[3]];
            t[3] = AES_SBOX[tmp];
            rcon = xtime8(rcon);
        }
        ctx->rk[i]   = (uint8_t)(ctx->rk[i-16]   ^ t[0]);
        ctx->rk[i+1] = (uint8_t)(ctx->rk[i-15]   ^ t[1]);
        ctx->rk[i+2] = (uint8_t)(ctx->rk[i-14]   ^ t[2]);
        ctx->rk[i+3] = (uint8_t)(ctx->rk[i-13]   ^ t[3]);
    }
}

static void aes128_block(const void *key_ctx, const uint8_t in[16], uint8_t out[16]) {
    const test_aes128_t *ctx = (const test_aes128_t *)key_ctx;
    uint8_t s[16], t[16];
    unsigned i, round, c;

    for (i = 0; i < 16; i++) s[i] = (uint8_t)(in[i] ^ ctx->rk[i]);

    for (round = 1; round < 10; round++) {
        for (i = 0; i < 16; i++) s[i] = AES_SBOX[s[i]];
        for (i = 0; i < 16; i++) {
            unsigned r = i % 4u, col = i / 4u;
            t[r + 4u * col] = s[r + 4u * ((col + r) % 4u)];
        }
        memcpy(s, t, 16);
        for (c = 0; c < 4; c++) {
            uint8_t a0 = s[4u*c], a1 = s[4u*c+1u], a2 = s[4u*c+2u], a3 = s[4u*c+3u];
            s[4u*c]   = (uint8_t)(xtime8(a0) ^ (uint8_t)(xtime8(a1) ^ a1) ^ a2 ^ a3);
            s[4u*c+1u] = (uint8_t)(a0 ^ xtime8(a1) ^ (uint8_t)(xtime8(a2) ^ a2) ^ a3);
            s[4u*c+2u] = (uint8_t)(a0 ^ a1 ^ xtime8(a2) ^ (uint8_t)(xtime8(a3) ^ a3));
            s[4u*c+3u] = (uint8_t)((uint8_t)(xtime8(a0) ^ a0) ^ a1 ^ a2 ^ xtime8(a3));
        }
        for (i = 0; i < 16; i++) s[i] = (uint8_t)(s[i] ^ ctx->rk[16u*round + i]);
    }

    for (i = 0; i < 16; i++) s[i] = AES_SBOX[s[i]];
    for (i = 0; i < 16; i++) {
        unsigned r = i % 4u, col = i / 4u;
        t[r + 4u * col] = s[r + 4u * ((col + r) % 4u)];
    }
    memcpy(s, t, 16);
    for (i = 0; i < 16; i++) out[i] = (uint8_t)(s[i] ^ ctx->rk[160u + i]);
}

static const uint8_t RFC4493_KEY[16] = {
    0x2b,0x7e,0x15,0x16,0x28,0xae,0xd2,0xa6,0xab,0xf7,0x15,0x88,0x09,0xcf,0x4f,0x3c
};
static const uint8_t RFC4493_K1[16] = {
    0xfb,0xee,0xd6,0x18,0x35,0x71,0x33,0x66,0x7c,0x85,0xe0,0x8f,0x72,0x36,0xa8,0xde
};
static const uint8_t RFC4493_K2[16] = {
    0xf7,0xdd,0xac,0x30,0x6a,0xe2,0x66,0xcc,0xf9,0x0b,0xc1,0x1e,0xe4,0x6d,0x51,0x3b
};
static const uint8_t RFC4493_EMPTY[16] = {
    0xbb,0x1d,0x69,0x29,0xe9,0x59,0x37,0x28,0x7f,0xa3,0x7d,0x12,0x9b,0x75,0x67,0x46
};

static void test_aes_kat(void) {
    test_aes128_t aes;
    uint8_t zero[16] = {0}, out[16];
    static const uint8_t want[16] = {
        0x7d,0xf7,0x6b,0x0c,0x1a,0xb8,0x99,0xb3,
        0x3e,0x42,0xf0,0x47,0xb9,0x1b,0x54,0x6f
    };
    aes128_init(&aes, RFC4493_KEY);
    aes128_block(&aes, zero, out);
    CHECK(memcmp(out, want, sizeof out) == 0);
}

static void test_cmac_subkeys_rfc(void) {
    test_aes128_t aes;
    uint8_t k1[16], k2[16];
    aes128_init(&aes, RFC4493_KEY);
    pc_cmac_subkeys(aes128_block, &aes, k1, k2);
    CHECK(memcmp(k1, RFC4493_K1, sizeof k1) == 0);
    CHECK(memcmp(k2, RFC4493_K2, sizeof k2) == 0);
}

static void test_cmac_empty_rfc(void) {
    test_aes128_t aes;
    uint8_t tag[16];
    aes128_init(&aes, RFC4493_KEY);
    pc_cmac(aes128_block, &aes, NULL, 0, tag);
    CHECK(memcmp(tag, RFC4493_EMPTY, sizeof tag) == 0);
}

static const uint8_t RFC4493_MSG[64] = {
    0x6b,0xc1,0xbe,0xe2,0x2e,0x40,0x9f,0x96,0xe9,0x3d,0x7e,0x11,0x73,0x93,0x17,0x2a,
    0xae,0x2d,0x8a,0x57,0x1e,0x03,0xac,0x9c,0x9e,0xb7,0x6f,0xac,0x45,0xaf,0x8e,0x51,
    0x30,0xc8,0x1c,0x46,0xa3,0x5c,0xe4,0x11,0xe5,0xfb,0xc1,0x19,0x1a,0x0a,0x52,0xef,
    0xf6,0x9f,0x24,0x45,0xdf,0x4f,0x9b,0x17,0xad,0x2b,0x41,0x7b,0xe6,0x6c,0x37,0x10
};
static const uint8_t RFC4493_TAG16[16] = {
    0x07,0x0a,0x16,0xb4,0x6b,0x4d,0x41,0x44,0xf7,0x9b,0xdd,0x9d,0xd0,0x4a,0x28,0x7c
};
static const uint8_t RFC4493_TAG40[16] = {
    0xdf,0xa6,0x67,0x47,0xde,0x9a,0xe6,0x30,0x30,0xca,0x32,0x61,0x14,0x97,0xc8,0x27
};
static const uint8_t RFC4493_TAG64[16] = {
    0x51,0xf0,0xbe,0xbf,0x7e,0x3b,0x9d,0x92,0xfc,0x49,0x74,0x17,0x79,0x36,0x3c,0xfe
};

static void test_cmac_lengths_rfc(void) {
    test_aes128_t aes;
    uint8_t tag[16], short_tag[PC_TAG_BYTES];

    aes128_init(&aes, RFC4493_KEY);

    pc_cmac(aes128_block, &aes, RFC4493_MSG, 16, tag);
    CHECK(memcmp(tag, RFC4493_TAG16, sizeof tag) == 0);

    pc_cmac(aes128_block, &aes, RFC4493_MSG, 40, tag);
    CHECK(memcmp(tag, RFC4493_TAG40, sizeof tag) == 0);

    pc_cmac(aes128_block, &aes, RFC4493_MSG, 64, tag);
    CHECK(memcmp(tag, RFC4493_TAG64, sizeof tag) == 0);

    pc_cmac_trunc(aes128_block, &aes, RFC4493_MSG, 64, short_tag);
    CHECK(memcmp(short_tag, RFC4493_TAG64, sizeof short_tag) == 0);
}

static void test_kdf_domain_separation(void) {
    static const uint8_t master[PC_MASTER_KEY_BYTES] = {
        0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
        0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f
    };
    static const uint8_t salt[] = { 'B','O','N','N','I','E','-','C','L','Y','D','E','-','v','1' };
    uint8_t send[PC_DERIVED_KEY_BYTES], recv[PC_DERIVED_KEY_BYTES];
    uint8_t again[PC_DERIVED_KEY_BYTES];
    uint8_t other_salt[sizeof salt], changed[PC_DERIVED_KEY_BYTES];

    pc_kdf(master, salt, sizeof salt, 0x01u, send);
    pc_kdf(master, salt, sizeof salt, 0x02u, recv);
    pc_kdf(master, salt, sizeof salt, 0x01u, again);
    memcpy(other_salt, salt, sizeof salt);
    other_salt[0] ^= 0x01u;
    pc_kdf(master, other_salt, sizeof other_salt, 0x01u, changed);

    CHECK(memcmp(send, recv, sizeof send) != 0);
    CHECK(memcmp(send, again, sizeof send) == 0);
    CHECK(memcmp(send, changed, sizeof send) != 0);
}

static void test_ctr_and_suite_round_trip(void) {
    static const uint8_t key[16] = {
        0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
        0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f
    };
    static const uint8_t nonce[PC_NONCE_BYTES] = {
        0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c
    };
    static const uint8_t aad[18] = {
        0x42,0x43,0x01,0x02,0x00,0x00,0x11,0x22,0x33,0x44,
        0x00,0x00,0x00,0x05,0x00,0x00,0x00,0x00
    };
    uint8_t plain[21], wire[21];
    uint8_t tag[PC_TAG_BYTES];
    size_t i;

    for (i = 0; i < sizeof plain; i++) plain[i] = (uint8_t)(0xA0u + (uint8_t)i);
    memcpy(wire, plain, sizeof plain);

    pc_suite_speck_ctr_cmac.seal(key, nonce, aad, sizeof aad,
                                 wire, sizeof wire, tag);
    CHECK(memcmp(wire, plain, sizeof plain) != 0);

    CHECK(pc_suite_speck_ctr_cmac.open(key, nonce, aad, sizeof aad,
                                       wire, sizeof wire, tag) == 0);
    CHECK(memcmp(wire, plain, sizeof plain) == 0);

    tag[0] ^= 0x01u;
    CHECK(pc_suite_speck_ctr_cmac.open(key, nonce, aad, sizeof aad,
                                       wire, sizeof wire, tag) != 0);
    CHECK(pc_suite_aead.seal == NULL || pc_suite_aead.open == NULL);
}

static void test_key_confirmation(void) {
    static const uint8_t key_a[16] = {
        0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
        0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f
    };
    static const uint8_t key_b[16] = {
        0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,
        0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f
    };
    static const uint8_t nonce[PC_CONFIRM_NONCE_BYTES] = {
        0xa1,0xa2,0xa3,0xa4,0xa5,0xa6,0xa7,0xa8
    };
    uint8_t tag[PC_CONFIRM_TAG_BYTES], bad[PC_CONFIRM_TAG_BYTES];
    const uint32_t session = 0x11223344u;

    pc_confirm_tag(key_a, 0x01u, session, 0u, nonce, tag);
    CHECK(pc_confirm_check(key_a, 0x01u, session, 0u, nonce, tag));
    CHECK(!pc_confirm_check(key_b, 0x01u, session, 0u, nonce, tag));
    CHECK(!pc_confirm_check(key_a, 0x02u, session, 0u, nonce, tag));
    CHECK(!pc_confirm_check(key_a, 0x01u, session + 1u, 0u, nonce, tag));
    memcpy(bad, tag, sizeof bad);
    bad[0] ^= 0x01u;
    CHECK(!pc_confirm_check(key_a, 0x01u, session, 0u, nonce, bad));
}

static void test_boot_self_test(void) {
    CHECK(proto_crypto_self_test() == true);
}

int main(void) {
    test_speck_kat_a();
    test_aes_kat();
    test_cmac_subkeys_rfc();
    test_cmac_empty_rfc();
    test_cmac_lengths_rfc();
    test_kdf_domain_separation();
    test_ctr_and_suite_round_trip();
    test_key_confirmation();
    test_boot_self_test();

    if (failures) {
        printf("crypto: %d failure(s)\n", failures);
        return 1;
    }
    printf("crypto: PASS\n");
    return 0;
}
