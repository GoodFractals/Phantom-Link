#include <stdio.h>
#include <string.h>

#include "proto_aead.h"

static int failures;

#define CHECK(cond)                                                            \
    do {                                                                       \
        if (!(cond)) {                                                         \
            printf("FAIL %s:%d: %s\n", __FILE__, __LINE__, #cond);             \
            failures++;                                                        \
        }                                                                      \
    } while (0)

/* ------------------------------------------------------------------------- */
/* RFC 8439 section 2.3.2: ChaCha20 block function test vector.               */
/* ------------------------------------------------------------------------- */
static const uint8_t CHACHA_BLOCK_KEY[CHACHA20_KEY_BYTES] = {
    0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
    0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
    0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,
    0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f
};
static const uint8_t CHACHA_BLOCK_NONCE[CHACHA20_NONCE_BYTES] = {
    0x00,0x00,0x00,0x09,0x00,0x00,0x00,0x4a,0x00,0x00,0x00,0x00
};
static const uint8_t CHACHA_BLOCK_WANT[CHACHA20_BLOCK_BYTES] = {
    0x10,0xf1,0xe7,0xe4,0xd1,0x3b,0x59,0x15,
    0x50,0x0f,0xdd,0x1f,0xa3,0x20,0x71,0xc4,
    0xc7,0xd1,0xf4,0xc7,0x33,0xc0,0x68,0x03,
    0x04,0x22,0xaa,0x9a,0xc3,0xd4,0x6c,0x4e,
    0xd2,0x82,0x64,0x46,0x07,0x9f,0xaa,0x09,
    0x14,0xc2,0xd7,0x05,0xd9,0x8b,0x02,0xa2,
    0xb5,0x12,0x9c,0xd1,0xde,0x16,0x4e,0xb9,
    0xcb,0xd0,0x83,0xe8,0xa2,0x50,0x3c,0x4e
};

static void test_chacha20_block_kat(void) {
    uint8_t out[CHACHA20_BLOCK_BYTES];

    chacha20_block(CHACHA_BLOCK_KEY, 1u, CHACHA_BLOCK_NONCE, out);
    CHECK(memcmp(out, CHACHA_BLOCK_WANT, sizeof out) == 0);
}

/* ------------------------------------------------------------------------- */
/* RFC 8439 section 2.6.2: Poly1305 one-time key generation KAT.              */
/* ------------------------------------------------------------------------- */
static const uint8_t POLYKEY_KEY[CHACHA20_KEY_BYTES] = {
    0x80,0x81,0x82,0x83,0x84,0x85,0x86,0x87,
    0x88,0x89,0x8a,0x8b,0x8c,0x8d,0x8e,0x8f,
    0x90,0x91,0x92,0x93,0x94,0x95,0x96,0x97,
    0x98,0x99,0x9a,0x9b,0x9c,0x9d,0x9e,0x9f
};
static const uint8_t POLYKEY_NONCE[CHACHA20_NONCE_BYTES] = {
    0x00,0x00,0x00,0x00,0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07
};
static const uint8_t POLYKEY_WANT[POLY1305_KEY_BYTES] = {
    0x8a,0xd5,0xa0,0x8b,0x90,0x5f,0x81,0xcc,
    0x81,0x50,0x40,0x27,0x4a,0xb2,0x94,0x71,
    0xa8,0x33,0xb6,0x37,0xe3,0xfd,0x0d,0xa5,
    0x08,0xdb,0xb8,0xe2,0xfd,0xd1,0xa6,0x46
};

static void test_poly1305_keygen_kat(void) {
    uint8_t out[CHACHA20_BLOCK_BYTES];

    chacha20_block(POLYKEY_KEY, 0u, POLYKEY_NONCE, out);
    CHECK(memcmp(out, POLYKEY_WANT, sizeof POLYKEY_WANT) == 0);
}

/* ------------------------------------------------------------------------- */
/* RFC 8439 section 2.5.2: Poly1305 MAC test vector.                          */
/* ------------------------------------------------------------------------- */
static const uint8_t POLY1305_KEY[POLY1305_KEY_BYTES] = {
    0x85,0xd6,0xbe,0x78,0x57,0x55,0x6d,0x33,
    0x7f,0x44,0x52,0xfe,0x42,0xd5,0x06,0xa8,
    0x01,0x03,0x80,0x8a,0xfb,0x0d,0xb2,0xfd,
    0x4a,0xbf,0xf6,0xaf,0x41,0x49,0xf5,0x1b
};
static const uint8_t POLY1305_MSG[34] = {
    0x43,0x72,0x79,0x70,0x74,0x6f,0x67,0x72,
    0x61,0x70,0x68,0x69,0x63,0x20,0x46,0x6f,
    0x72,0x75,0x6d,0x20,0x52,0x65,0x73,0x65,
    0x61,0x72,0x63,0x68,0x20,0x47,0x72,0x6f,
    0x75,0x70
};
static const uint8_t POLY1305_WANT[POLY1305_TAG_BYTES] = {
    0xa8,0x06,0x1d,0xc1,0x30,0x51,0x36,0xc6,
    0xc2,0x2b,0x8b,0xaf,0x0c,0x01,0x27,0xa9
};

static void test_poly1305_kat(void) {
    uint8_t tag[POLY1305_TAG_BYTES];

    poly1305(POLY1305_KEY, POLY1305_MSG, sizeof POLY1305_MSG, tag);
    CHECK(memcmp(tag, POLY1305_WANT, sizeof tag) == 0);

    /* A zero-length message is legal and must not dereference a NULL pointer. */
    poly1305(POLY1305_KEY, NULL, 0u, tag);
}

/* ------------------------------------------------------------------------- */
/* RFC 8439 section 2.8.2: full AEAD_CHACHA20_POLY1305 test vector.           */
/* The suite truncates the 16-byte tag to its first 8 bytes (MSB-first).      */
/* ------------------------------------------------------------------------- */
static const uint8_t AEAD_KAT_KEY[AEAD_KEY_BYTES] = {
    0x80,0x81,0x82,0x83,0x84,0x85,0x86,0x87,
    0x88,0x89,0x8a,0x8b,0x8c,0x8d,0x8e,0x8f,
    0x90,0x91,0x92,0x93,0x94,0x95,0x96,0x97,
    0x98,0x99,0x9a,0x9b,0x9c,0x9d,0x9e,0x9f
};
static const uint8_t AEAD_KAT_NONCE[AEAD_NONCE_BYTES] = {
    0x07,0x00,0x00,0x00,0x40,0x41,0x42,0x43,0x44,0x45,0x46,0x47
};
static const uint8_t AEAD_KAT_AAD[12] = {
    0x50,0x51,0x52,0x53,0xc0,0xc1,0xc2,0xc3,0xc4,0xc5,0xc6,0xc7
};
static const uint8_t AEAD_KAT_PT[114] = {
    0x4c,0x61,0x64,0x69,0x65,0x73,0x20,0x61,
    0x6e,0x64,0x20,0x47,0x65,0x6e,0x74,0x6c,
    0x65,0x6d,0x65,0x6e,0x20,0x6f,0x66,0x20,
    0x74,0x68,0x65,0x20,0x63,0x6c,0x61,0x73,
    0x73,0x20,0x6f,0x66,0x20,0x27,0x39,0x39,
    0x3a,0x20,0x49,0x66,0x20,0x49,0x20,0x63,
    0x6f,0x75,0x6c,0x64,0x20,0x6f,0x66,0x66,
    0x65,0x72,0x20,0x79,0x6f,0x75,0x20,0x6f,
    0x6e,0x6c,0x79,0x20,0x6f,0x6e,0x65,0x20,
    0x74,0x69,0x70,0x20,0x66,0x6f,0x72,0x20,
    0x74,0x68,0x65,0x20,0x66,0x75,0x74,0x75,
    0x72,0x65,0x2c,0x20,0x73,0x75,0x6e,0x73,
    0x63,0x72,0x65,0x65,0x6e,0x20,0x77,0x6f,
    0x75,0x6c,0x64,0x20,0x62,0x65,0x20,0x69,
    0x74,0x2e
};
static const uint8_t AEAD_KAT_CT[114] = {
    0xd3,0x1a,0x8d,0x34,0x64,0x8e,0x60,0xdb,
    0x7b,0x86,0xaf,0xbc,0x53,0xef,0x7e,0xc2,
    0xa4,0xad,0xed,0x51,0x29,0x6e,0x08,0xfe,
    0xa9,0xe2,0xb5,0xa7,0x36,0xee,0x62,0xd6,
    0x3d,0xbe,0xa4,0x5e,0x8c,0xa9,0x67,0x12,
    0x82,0xfa,0xfb,0x69,0xda,0x92,0x72,0x8b,
    0x1a,0x71,0xde,0x0a,0x9e,0x06,0x0b,0x29,
    0x05,0xd6,0xa5,0xb6,0x7e,0xcd,0x3b,0x36,
    0x92,0xdd,0xbd,0x7f,0x2d,0x77,0x8b,0x8c,
    0x98,0x03,0xae,0xe3,0x28,0x09,0x1b,0x58,
    0xfa,0xb3,0x24,0xe4,0xfa,0xd6,0x75,0x94,
    0x55,0x85,0x80,0x8b,0x48,0x31,0xd7,0xbc,
    0x3f,0xf4,0xde,0xf0,0x8e,0x4b,0x7a,0x9d,
    0xe5,0x76,0xd2,0x65,0x86,0xce,0xc6,0x4b,
    0x61,0x16
};
static const uint8_t AEAD_KAT_TAG8[AEAD_TAG_BYTES] = {
    0x1a,0xe1,0x0b,0x59,0x4f,0x09,0xe2,0x6a
};

static void test_aead_kat_seal(void) {
    uint8_t buf[sizeof AEAD_KAT_PT];
    uint8_t tag[AEAD_TAG_BYTES];

    memcpy(buf, AEAD_KAT_PT, sizeof buf);
    aead_seal(AEAD_KAT_KEY, AEAD_KAT_NONCE,
              AEAD_KAT_AAD, sizeof AEAD_KAT_AAD,
              buf, sizeof buf, tag);
    CHECK(memcmp(buf, AEAD_KAT_CT, sizeof buf) == 0);
    CHECK(memcmp(tag, AEAD_KAT_TAG8, sizeof tag) == 0);
}

static void test_aead_kat_open(void) {
    uint8_t buf[sizeof AEAD_KAT_CT];

    memcpy(buf, AEAD_KAT_CT, sizeof buf);
    CHECK(aead_open(AEAD_KAT_KEY, AEAD_KAT_NONCE,
                    AEAD_KAT_AAD, sizeof AEAD_KAT_AAD,
                    buf, sizeof buf, AEAD_KAT_TAG8) == 0);
    CHECK(memcmp(buf, AEAD_KAT_PT, sizeof buf) == 0);
}

/* ------------------------------------------------------------------------- */
/* Suite ops, frame-sized AAD (18 bytes), round trip and tamper rejection.    */
/* ------------------------------------------------------------------------- */
static void test_suite_round_trip(void) {
    static const uint8_t key[AEAD_KEY_BYTES] = {
        0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
        0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
        0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,
        0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f
    };
    static const uint8_t nonce[AEAD_NONCE_BYTES] = {
        0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c
    };
    uint8_t aad[AEAD_AAD_BYTES] = {
        0x42,0x43,0x01,0x02,0x00,0x00,0x11,0x22,0x33,
        0x44,0x00,0x00,0x00,0x05,0x00,0x00,0x00,0x00
    };
    uint8_t plain[21], buf[21], tag[AEAD_TAG_BYTES];
    size_t i;

    CHECK(aead_suite_chacha20_poly1305.seal != NULL);
    CHECK(aead_suite_chacha20_poly1305.open != NULL);

    for (i = 0u; i < sizeof plain; i++) plain[i] = (uint8_t)(0xa0u + (uint8_t)i);
    memcpy(buf, plain, sizeof buf);

    aead_suite_chacha20_poly1305.seal(key, nonce, aad, sizeof aad,
                                      buf, sizeof buf, tag);
    CHECK(memcmp(buf, plain, sizeof buf) != 0);
    CHECK(aead_suite_chacha20_poly1305.open(key, nonce, aad, sizeof aad,
                                            buf, sizeof buf, tag) == 0);
    CHECK(memcmp(buf, plain, sizeof buf) == 0);
}

/* A rejected frame must be left untouched: the tag is verified before any
 * decryption is performed. */
static void test_verify_before_decrypt(void) {
    static const uint8_t key[AEAD_KEY_BYTES] = {
        0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
        0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
        0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,
        0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f
    };
    static const uint8_t nonce[AEAD_NONCE_BYTES] = {
        0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c
    };
    uint8_t aad[AEAD_AAD_BYTES], plain[21], wire[21], tag[AEAD_TAG_BYTES];
    uint8_t bad_tag[AEAD_TAG_BYTES], working[21];
    size_t i;

    for (i = 0u; i < sizeof aad; i++) aad[i] = (uint8_t)i;
    for (i = 0u; i < sizeof plain; i++) plain[i] = (uint8_t)(0x40u + (uint8_t)i);
    memcpy(wire, plain, sizeof wire);
    aead_seal(key, nonce, aad, sizeof aad, wire, sizeof wire, tag);

    memcpy(bad_tag, tag, sizeof bad_tag);
    bad_tag[0] ^= 0x01u;
    memcpy(working, wire, sizeof working);
    CHECK(aead_open(key, nonce, aad, sizeof aad,
                    working, sizeof working, bad_tag) != 0);
    CHECK(memcmp(working, wire, sizeof working) == 0); /* not decrypted */

    /* A valid frame immediately after a rejection still opens. */
    CHECK(aead_open(key, nonce, aad, sizeof aad,
                    wire, sizeof wire, tag) == 0);
    CHECK(memcmp(wire, plain, sizeof wire) == 0);
}

/* Exhaustive single-bit tamper sweep over tag, AAD and ciphertext. */
static void test_single_bit_tamper(void) {
    static const uint8_t key[AEAD_KEY_BYTES] = {
        0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
        0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
        0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,
        0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f
    };
    static const uint8_t nonce[AEAD_NONCE_BYTES] = {
        0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c
    };
    uint8_t aad[AEAD_AAD_BYTES], wire[21], tag[AEAD_TAG_BYTES];
    uint8_t bad_aad[AEAD_AAD_BYTES], bad_wire[21], bad_tag[AEAD_TAG_BYTES];
    size_t i;
    unsigned bit;

    for (i = 0u; i < sizeof aad; i++) aad[i] = (uint8_t)i;
    for (i = 0u; i < sizeof wire; i++) wire[i] = (uint8_t)(0x40u + (uint8_t)i);
    aead_seal(key, nonce, aad, sizeof aad, wire, sizeof wire, tag);

    for (i = 0u; i < sizeof bad_tag; i++) {
        for (bit = 0u; bit < 8u; bit++) {
            memcpy(bad_tag, tag, sizeof bad_tag);
            bad_tag[i] ^= (uint8_t)(1u << bit);
            CHECK(aead_open(key, nonce, aad, sizeof aad, wire, sizeof wire,
                            bad_tag) != 0);
        }
    }
    for (i = 0u; i < sizeof aad; i++) {
        for (bit = 0u; bit < 8u; bit++) {
            memcpy(bad_aad, aad, sizeof bad_aad);
            bad_aad[i] ^= (uint8_t)(1u << bit);
            CHECK(aead_open(key, nonce, bad_aad, sizeof bad_aad,
                            wire, sizeof wire, tag) != 0);
        }
    }
    for (i = 0u; i < sizeof wire; i++) {
        for (bit = 0u; bit < 8u; bit++) {
            memcpy(bad_wire, wire, sizeof bad_wire);
            bad_wire[i] ^= (uint8_t)(1u << bit);
            CHECK(aead_open(key, nonce, aad, sizeof aad,
                            bad_wire, sizeof bad_wire, tag) != 0);
        }
    }
    CHECK(aead_open(key, nonce, aad, sizeof aad,
                    wire, sizeof wire, tag) == 0);
}

static void test_self_test(void) {
    CHECK(aead_self_test() == true);
}

int main(void) {
    test_chacha20_block_kat();
    test_poly1305_keygen_kat();
    test_poly1305_kat();
    test_aead_kat_seal();
    test_aead_kat_open();
    test_suite_round_trip();
    test_verify_before_decrypt();
    test_single_bit_tamper();
    test_self_test();

    if (failures) {
        printf("aead: %d failure(s)\n", failures);
        return 1;
    }
    printf("aead: PASS\n");
    return 0;
}
